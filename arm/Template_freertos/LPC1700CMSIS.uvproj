# Keil uVision project LPC1700CMSIS.uvproj, settings and files
target LPC1700 FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1700CMSIS +hex
  AfterMake: fromelf --bin ".\Flash\LPC1700CMSIS.axf" --output ".\Flash\LPC1700CMSIS.bin"
  c flags: Optim=4 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0
  c include: .\src\cmsis\DeviceSupport\NXP\LPC17xx;.\src\cmsis\DriverSupport\include;.\src\harness;.\src\freertos\include;.\src\freertos\portable
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./src/cmsis/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS-CM3
    ./src/cmsis/CoreSupport/: core_cm3.c
    ./src/cmsis/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group FreeRTOS
    ./src/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ./src/freertos/portable/: port.c portmacro.h
    ./src/freertos/: croutine.c list.c queue.c readme.txt tasks.c timers.c heap_1.c
  group Harness
    ./src/harness/: FreeRTOSConfig.h lpc17xx_libcfg.h main.c ParTest.c partest.h type.h
target LPC1700 RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPC1700CMSIS
  c flags: Optim=1 wLevel=1
  c define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=1
  c include: .\src\cmsis\DeviceSupport\NXP\LPC17xx;.\src\cmsis\DriverSupport\include;.\src\myapp;.\src\lpcusb;.\src\freertos\include;.\src\freertos\portable;.\src\freertos
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
